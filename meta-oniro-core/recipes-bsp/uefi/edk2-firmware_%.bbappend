COMPATIBLE_MACHINE:qemuarm-efi   = "qemuarm-efi"
EDK2_PLATFORM:qemuarm-efi        = "ArmVirtQemu"
EDK2_PLATFORM_DSC:qemuarm-efi    = "ArmVirtPkg/ArmVirtQemu.dsc"
EDK2_BIN_NAME:qemuarm-efi        = "QEMU_EFI.fd"
