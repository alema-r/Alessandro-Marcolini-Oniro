# SPDX-FileCopyrightText: Huawei Inc.
#
# SPDX-License-Identifier: MIT

require recipes-core/images/core-image-base.bb
require oniro-image-common.inc

SUMMARY = "Oniro Project image including the base OS software stack"
