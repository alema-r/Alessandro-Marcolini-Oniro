# SPDX-FileCopyrightText: Huawei Inc.
#
# SPDX-License-Identifier: Apache-2.0

require recipes-core/images/allscenarios-image-base.bb

SUMMARY = "Gateway blueprint image"
DESCRIPTION = "Smart home gateway device"
LICENSE = "Apache-2.0"
