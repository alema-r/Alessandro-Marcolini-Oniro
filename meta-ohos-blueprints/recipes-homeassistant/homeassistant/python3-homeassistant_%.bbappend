# SPDX-FileCopyrightText: 2021 Huawei Inc.
#
# SPDX-License-Identifier: Apache-2.0

RRECOMMENDS_${PN} += "smart-home-homeassistant-plugin"
