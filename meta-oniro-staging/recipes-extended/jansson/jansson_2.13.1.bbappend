# upstream considers it isn't a real bug https://github.com/akheron/jansson/issues/548
CVE_CHECK_WHITELIST = "CVE-2020-36325 "
