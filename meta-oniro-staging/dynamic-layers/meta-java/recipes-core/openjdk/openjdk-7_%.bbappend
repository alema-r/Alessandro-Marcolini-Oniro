# SPDX-FileCopyrightText: Huawei Inc.
#
# SPDX-License-Identifier: MIT

PACKAGECONFIG ??= ""
