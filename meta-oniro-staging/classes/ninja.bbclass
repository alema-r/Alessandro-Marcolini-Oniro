# SPDX-FileCopyrightText: Huawei Inc.
#
# SPDX-License-Identifier: MIT

DEPENDS:prepend = "ninja-native "

MAXLOAD_NINJA ??= "0"
export MAXLOAD_NINJA
