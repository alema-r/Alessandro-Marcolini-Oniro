# SPDX-FileCopyrightText: Huawei Inc.
#
# SPDX-License-Identifier: Apache-2.0

include recipes-core/classpath/classpath-features-check.inc
