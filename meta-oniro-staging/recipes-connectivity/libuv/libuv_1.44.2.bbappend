# SPDX-FileCopyrightText: Huawei Inc.
#
# SPDX-License-Identifier: MIT

BBCLASSEXTEND:append = " nativesdk"
