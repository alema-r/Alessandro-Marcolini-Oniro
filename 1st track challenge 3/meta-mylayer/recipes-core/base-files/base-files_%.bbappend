
do_install_basefilesissue:append () {
   echo "alema-r" >> ${D}${sysconfdir}/issue
}
