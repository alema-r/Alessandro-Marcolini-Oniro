FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SPLASH_IMAGES = "file://ostc-logo-small.png;outsuffix=default"
