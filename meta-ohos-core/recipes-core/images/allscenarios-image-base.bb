# SPDX-FileCopyrightText: Huawei Inc.
#
# SPDX-License-Identifier: Apache-2.0

require recipes-core/images/core-image-base.bb
require allscenarios-image-common.inc

SUMMARY = "AllScenariOS image including the base OS software stack"
